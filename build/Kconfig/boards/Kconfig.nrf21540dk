## build/Kconfig/boards/Kconfig.nrf21540dk
```kconfig
# Load board Kconfig descriptions.
osource "C:/ncs/v2.9.0/zephyr/boards/nordic/nrf21540dk/Kconfig.nrf21540dk"
```
